# IAR project light_external_lna_prs_mg21_v655.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG21A010F1024IM32 SiliconLaboratories EFR32MG21A010F1024IM32
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: LOCAL_STORAGE_BTL; CORTEXM3; CORTEXM3_EFR32; CORTEXM3_EFR32_MICRO; CORTEXM3_EFM32_MICRO; EFR32_SERIES2_CONFIG1_MICRO; EFR32MG21; EFR32MG21A010F1024IM32; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/light_external_lna_prs_mg21_v655/light_external_lna_prs_mg21_v655_endpoint_config.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/light_external_lna_prs_mg21_v655/light_external_lna_prs_mg21_v655_tokens.h"; PLATFORM_HEADER="platform/base/hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/light_external_lna_prs_mg21_v655/light_external_lna_prs_mg21_v655.h"; __SOURCEFILE__="$FILE_FNAME$"; HAL_CONFIG=1; EMBER_AF_USE_HWCONF; NO_LED=1; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"; EMBER_AF_API_DEBUG_PRINT="app/framework/util/print.h"; EMBER_AF_API_AF_HEADER="app/framework/include/af.h"; EMBER_AF_API_AF_SECURITY_HEADER="app/framework/security/af-security.h"; EMBER_STACK_ZIGBEE; USE_NVM3; NVM3_DEFAULT_NVM_SIZE=NVM3_FLASH_PAGES*FLASH_PAGE_SIZE; EMLIB_USER_CONFIG; APPLICATION_TOKEN_HEADER="app/builder/light_external_lna_prs_mg21_v655/afv2-token.h"; APPLICATION_MFG_TOKEN_HEADER="app/builder/light_external_lna_prs_mg21_v655/afv2-mfg-token.h"; NVM3_FLASH_PAGES=4; NVM3_DEFAULT_CACHE_SIZE=200; NVM3_MAX_OBJECT_SIZE=254; NVM3_DEFAULT_REPACK_HEADROOM=0; PHY_RAIL=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; ..\..\..; ..\..\..\protocol\zigbee\app\framework; ..\..\..\protocol\zigbee\app\framework\..\..; ..\..\..\protocol\zigbee\app\framework\..\..\stack; ..\..\..\protocol\zigbee\app\framework\..\util; ..\..\..\protocol\zigbee\app\framework\include; ..\..\..\platform\base\hal; ..\..\..\platform\base\hal\plugin; ..\..\..\platform\base\hal\..; ..\..\..\platform\base\hal\micro\cortexm3\efm32; ..\..\..\platform\base\hal\micro\cortexm3\efm32\config; ..\..\..\platform\base\hal\micro\cortexm3\efm32\efr32; ..\..\..\platform\base\hal\..\..\CMSIS\Include; ..\..\..\platform\base\hal\..\..\Device\SiliconLabs\efr32mg21\Include; ..\..\..\platform\base\hal\..\..\emdrv\common\inc; ..\..\..\platform\base\hal\..\..\emdrv\config; ..\..\..\platform\base\hal\..\..\emdrv\dmadrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\gpiointerrupt\inc; ..\..\..\platform\base\hal\..\..\emdrv\rtcdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\sleep\inc; ..\..\..\platform\base\hal\..\..\emdrv\spidrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\tempdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\uartdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\ustimer\inc; ..\..\..\platform\base\hal\..\..\emlib\inc; ..\..\..\platform\base\hal\..\..\middleware\glib; ..\..\..\platform\base\hal\..\..\middleware\glib\glib; ..\..\..\platform\base\hal\..\..\radio\rail_lib\plugin; ..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\rfprotocol\ieee802154\cortex; ..\..\..\platform\halconfig\inc\hal-config; ..\..\..\hardware\module\config; ..\..\..\hardware\kit\common\halconfig; ..\..\..\hardware\kit\common\bsp; ..\..\..\platform\bootloader; hal-config; ..\..\..\platform\emdrv\nvm3\inc; ..\..\..\platform\radio\rail_lib\common; ..\..\..\platform\radio\rail_lib\protocol\ble; ..\..\..\platform\radio\rail_lib\protocol\ieee802154; ..\..\..\platform\radio\rail_lib\protocol\zwave; ..\..\..\platform\radio\rail_lib\chip\efr32\efr32xg2x; ..\..\..\platform\radio\rail_lib\plugin\coexistence\common; ..\..\..\platform\radio\rail_lib\plugin\coexistence\protocol\ieee802154; ..\..\..\platform\radio\rail_lib\plugin\coexistence\hal\efr32
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: LOCAL_STORAGE_BTL; CORTEXM3; CORTEXM3_EFM32_MICRO; CORTEXM3_EFR32_MICRO; CORTEXM3_EFR32; EFR32_SERIES2_CONFIG1_MICRO; EFR32MG21; EFR32MG21A010F1024IM32; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/light_external_lna_prs_mg21_v655/light_external_lna_prs_mg21_v655_endpoint_config.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/light_external_lna_prs_mg21_v655/light_external_lna_prs_mg21_v655_tokens.h"; PLATFORM_HEADER="platform/base/hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/light_external_lna_prs_mg21_v655/light_external_lna_prs_mg21_v655.h"; HAL_CONFIG=1; EMBER_AF_USE_HWCONF; NO_LED=1; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"; EMBER_AF_API_DEBUG_PRINT="app/framework/util/print.h"; EMBER_AF_API_AF_HEADER="app/framework/include/af.h"; EMBER_AF_API_AF_SECURITY_HEADER="app/framework/security/af-security.h"; EMBER_STACK_ZIGBEE; USE_NVM3; NVM3_DEFAULT_NVM_SIZE=NVM3_FLASH_PAGES*FLASH_PAGE_SIZE; EMLIB_USER_CONFIG; APPLICATION_TOKEN_HEADER="app/builder/light_external_lna_prs_mg21_v655/afv2-token.h"; APPLICATION_MFG_TOKEN_HEADER="app/builder/light_external_lna_prs_mg21_v655/afv2-mfg-token.h"; NVM3_FLASH_PAGES=4; NVM3_DEFAULT_CACHE_SIZE=200; NVM3_MAX_OBJECT_SIZE=254; NVM3_DEFAULT_REPACK_HEADROOM=0; PHY_RAIL=1
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; ..\..\..; ..\..\..\protocol\zigbee\app\framework; ..\..\..\protocol\zigbee\app\framework\..\..; ..\..\..\protocol\zigbee\app\framework\..\..\stack; ..\..\..\protocol\zigbee\app\framework\..\util; ..\..\..\protocol\zigbee\app\framework\include; ..\..\..\platform\base\hal; ..\..\..\platform\base\hal\plugin; ..\..\..\platform\base\hal\..; ..\..\..\platform\base\hal\micro\cortexm3\efm32; ..\..\..\platform\base\hal\micro\cortexm3\efm32\config; ..\..\..\platform\base\hal\micro\cortexm3\efm32\efr32; ..\..\..\platform\base\hal\..\..\CMSIS\Include; ..\..\..\platform\base\hal\..\..\Device\SiliconLabs\efr32mg21\Include; ..\..\..\platform\base\hal\..\..\emdrv\common\inc; ..\..\..\platform\base\hal\..\..\emdrv\config; ..\..\..\platform\base\hal\..\..\emdrv\dmadrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\gpiointerrupt\inc; ..\..\..\platform\base\hal\..\..\emdrv\rtcdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\rtcdrv\test; ..\..\..\platform\base\hal\..\..\emdrv\sleep\inc; ..\..\..\platform\base\hal\..\..\emdrv\spidrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\tempdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\uartdrv\inc; ..\..\..\platform\base\hal\..\..\emdrv\ustimer\inc; ..\..\..\platform\base\hal\..\..\emlib\inc; ..\..\..\platform\base\hal\..\..\middleware\glib; ..\..\..\platform\base\hal\..\..\middleware\glib\glib; ..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\platform\base\hal\..\..\radio\rail_lib\chip\efr32\rf\rfprotocol\ieee802154\cortex; ..\..\..\platform\halconfig\inc\hal-config; ..\..\..\hardware\kit\common\halconfig; ..\..\..\hardware\kit\common\bsp; ..\..\..\platform\bootloader; hal-config; ..\..\..\platform\emdrv\nvm3\inc; ..\..\..\platform\radio\rail_lib\common; ..\..\..\platform\radio\rail_lib\protocol\ble; ..\..\..\platform\radio\rail_lib\protocol\ieee802154; ..\..\..\platform\radio\rail_lib\protocol\zwave; ..\..\..\platform\radio\rail_lib\chip\efr32\efr32xg2x; ..\..\..\platform\radio\rail_lib\plugin\coexistence\common; ..\..\..\platform\radio\rail_lib\plugin\coexistence\protocol\ieee802154; ..\..\..\platform\radio\rail_lib\plugin\coexistence\hal\efr32
  OBJCOPY.OOCOutputFile: light_external_lna_prs_mg21_v655.s37
  prebuild: light_external_lna_prs_mg21_v655-prebuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$' 'C:\SiliconLabs\SimplicityStudio\v4'
  postbuild: light_external_lna_prs_mg21_v655-postbuild.bat '$TARGET_BPATH$' '$PROJ_DIR$' '$TOOLKIT_DIR$' 'C:\SiliconLabs\SimplicityStudio\v4'
  ILINK.IlinkOutputFile: light_external_lna_prs_mg21_v655.out
  ILINK.IlinkConfigDefines: FLASH_SIZE=1048576; RAM_SIZE=98304; SIMEEPROM_SIZE=32768; LOCKBITS_IN_MAINFLASH_SIZE=8192; LOCAL_STORAGE_BTL=1; EMBER_MALLOC_HEAP_SIZE=0
  ILINK.IlinkIcfFile: ..\..\..\platform\base\hal\micro\cortexm3\efm32\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../app/builder/light_external_lna_prs_mg21_v655/: light_external_lna_prs_mg21_v655_callbacks.c
    ../../../platform/base/hal/micro/cortexm3/efm32/: bootloader-interface-app.c bootloader-interface.c hal-config.c hal-config-gpio.c assert-crash-handlers.c button.c cstartup-common.c diagnostic.c faults-v7m.s79 isr-stubs.s79 led.c mfg-token.c micro-common.c micro.c mpu.c sleep-efm32.c token.c ext-device.c
    ../../../platform/base/hal/plugin/serial/cortexm/efm32/: com.c
    ../../../platform/bootloader/api/: btl_interface.c btl_interface_storage.c
    ../../../platform/emdrv/uartdrv/src/: uartdrv.c
    ../../../platform/base/hal/plugin/adc/: adc-efr32.c
    ../../../protocol/zigbee/app/framework/plugin/aes-cmac/: aes-cmac.c
    ../../../platform/base/hal/plugin/antenna-stub/: antenna-stub.c
    ../../../protocol/zigbee/app/framework/plugin/basic/: basic.c
    ../../../util/plugin/plugin-common/battery-monitor/: battery-monitor-efr32.c
    ../../../platform/radio/rail_lib/plugin/coexistence/protocol/ieee802154/: coexistence-802154.c
    ../../../platform/radio/rail_lib/plugin/coexistence/hal/efr32/: coexistence-hal.c coexistence-directional-priority.c
    ../../../platform/radio/rail_lib/plugin/coexistence/common/: coexistence.c
    ../../../protocol/zigbee/app/framework/plugin/color-control-server/: color-control-server.c
    ../../../protocol/zigbee/app/framework/plugin/counters/: counters-cli.c counters-ota.c counters-soc.c
    ../../../platform/base/hal/plugin/debug/rtt/: SEGGER_RTT.c
    ../../../platform/base/hal/plugin/debug-jtag-stub/: debug-jtag-stub.c
    ../../../platform/base/hal/plugin/serial/: ember-printf.c serial.c
    ../../../protocol/zigbee/app/framework/plugin/find-and-bind-target/: find-and-bind-target.c find-and-bind-target-cli.c
    ../../../protocol/zigbee/app/framework/plugin/form-and-join/: form-and-join-afv2.c
    ../../../protocol/zigbee/app/util/common/: form-and-join.c form-and-join-node-adapter.c
    ../../../util/plugin/plugin-common/generic-interrupt-control/: generic-interrupt-control-efr32.c
    ../../../protocol/zigbee/app/framework/plugin/green-power-client/: green-power-client.c green-power-client-cli.c
    ../../../protocol/zigbee/app/framework/plugin/green-power-common/: green-power-common.c
    ../../../protocol/zigbee/app/framework/plugin/groups-server/: groups-server.c groups-server-cli.c
    ../../../protocol/zigbee/app/framework/plugin/heartbeat/: heartbeat.c
    ../../../protocol/zigbee/app/framework/plugin/identify/: identify.c identify-cli.c
    ../../../protocol/zigbee/app/framework/plugin/interpan/: interpan.c interpan-cli.c interpan-soc.c
    ../../../protocol/zigbee/app/framework/plugin/level-control/: level-control.c
    ../../../protocol/zigbee/app/framework/plugin/network-creator/: network-creator.c network-creator-cli.c
    ../../../protocol/zigbee/app/framework/plugin/network-creator-security/: network-creator-security.c network-creator-security-cli.c
    ../../../protocol/zigbee/app/framework/plugin/network-steering/: network-steering.c network-steering-cli.c network-steering-soc.c
    ../../../platform/emdrv/nvm3/src/: nvm3_lock.c nvm3_default.c nvm3_hal_flash.c
    ../../../protocol/zigbee/app/framework/plugin/on-off/: on-off.c
    ../../../protocol/zigbee/app/framework/plugin/reporting/: reporting.c reporting-cli.c reporting-default-configuration.c
    ../../../protocol/zigbee/app/framework/plugin/scan-dispatch/: scan-dispatch.c
    ../../../protocol/zigbee/app/framework/plugin/scenes/: scenes.c scenes-cli.c
    ../../../protocol/zigbee/app/framework/plugin/simple-main/: simple-main.c
    ../../../protocol/zigbee/app/framework/plugin/update-tc-link-key/: update-tc-link-key.c update-tc-link-key-cli.c
    ../../../protocol/zigbee/app/framework/plugin/zll-commissioning-common/: zll-commissioning-common.c zll-commissioning-cli.c
    ../../../protocol/zigbee/app/framework/plugin/zll-commissioning-server/: zll-commissioning-server.c
    ../../../protocol/zigbee/app/framework/plugin/zll-identify-server/: zll-identify-server.c
    ../../../protocol/zigbee/app/framework/plugin/zll-level-control-server/: zll-level-control-server.c
    ../../../protocol/zigbee/app/framework/plugin/zll-on-off-server/: zll-on-off-server.c
    ../../../protocol/zigbee/app/framework/plugin/zll-scenes-server/: zll-scenes-server.c
    ../../../protocol/zigbee/app/framework/plugin/zll-utility-server/: zll-utility-server.c
    ./: afv2-bookkeeping.c call-command-handler.c callback-stub.c stack-handler-stub.c cli.c
    ../../../protocol/zigbee/app/framework/util/: af-event.c af-main-common.c af-main-soc.c attribute-size.c attribute-storage.c attribute-table.c client-api.c print.c print-formatter.c process-cluster-message.c process-global-message.c service-discovery-common.c service-discovery-soc.c message.c multi-network.c time-util.c util.c
    ../../../protocol/zigbee/app/framework/security/: af-node.c af-security-common.c af-trust-center.c crypto-state.c
    ../../../platform/base/hal/plugin/buzzer/: buzzer-efr32.c
    ../../../protocol/zigbee/app/framework/../util/serial/: command-interpreter2.c
    ../../../platform/base/hal/micro/generic/: crc.c endian.c mem-util.c random.c token-def.c
    ../../../protocol/zigbee/app/framework/../../stack/config/: ember-configuration.c
    ../../../protocol/zigbee/app/framework/../util/common/: library.c
    ../../../protocol/zigbee/app/framework/cli/: core-cli.c network-cli.c option-cli.c plugin-cli.c security-cli.c zcl-cli.c zdo-cli.c
    ../../../protocol/zigbee/app/framework/../util/security/: security-address-cache.c
    ../../../platform/base/hal/: ember-base-configuration.c
    ../../../protocol/zigbee/app/framework/../util/zigbee-framework/: zigbee-device-common.c zigbee-device-library.c
  group emdrv
    ../../../platform/base/hal/../../emdrv/dmadrv/src/: dmadrv.c
    ../../../platform/base/hal/../../emdrv/gpiointerrupt/src/: gpiointerrupt.c
    ../../../platform/base/hal/../../emdrv/rtcdrv/src/: rtcdriver.c
    ../../../platform/base/hal/../../emdrv/sleep/src/: sleep.c
    ../../../platform/base/hal/../../emdrv/tempdrv/src/: tempdrv.c
    ../../../platform/base/hal/../../emdrv/ustimer/src/: ustimer.c
  group emlib
    ../../../platform/base/hal/../../emlib/src/: em_adc.c em_cmu.c em_core.c em_cryotimer.c em_emu.c em_gpio.c em_i2c.c em_ldma.c em_leuart.c em_msc.c em_prs.c em_rmu.c em_rtcc.c em_se.c em_system.c em_timer.c em_usart.c em_wdog.c
    ../../../platform/base/hal/../../Device/SiliconLabs/EFR32MG21/Source/: system_efr32mg21.c
  group Libraries
    ../../../protocol/zigbee/build/binding-table-library-cortexm3-iar-efr32mg21-rail/: binding-table-library.a
    ../../../protocol/zigbee/build/cbke-163k1-stub-library-cortexm3-iar-efr32mg21-rail/: cbke-163k1-stub-library.a
    ../../../protocol/zigbee/build/cbke-283k1-stub-library-cortexm3-iar-efr32mg21-rail/: cbke-283k1-stub-library.a
    ../../../protocol/zigbee/build/cbke-stub-library-cortexm3-iar-efr32mg21-rail/: cbke-stub-library.a
    ../../../protocol/zigbee/build/cbke-library-dsa-sign-stub-cortexm3-iar-efr32mg21-rail/: cbke-library-dsa-sign-stub.a
    ../../../protocol/zigbee/build/cbke-library-dsa-verify-stub-cortexm3-iar-efr32mg21-rail/: cbke-library-dsa-verify-stub.a
    ../../../protocol/zigbee/build/cbke-library-dsa-verify-283k1-stub-cortexm3-iar-efr32mg21-rail/: cbke-library-dsa-verify-283k1-stub.a
    ../../../protocol/zigbee/build/debug-basic-library-cortexm3-iar-efr32mg21-rail/: debug-basic-library.a
    ../../../protocol/zigbee/build/debug-extended-stub-library-cortexm3-iar-efr32mg21-rail/: debug-extended-stub-library.a
    ../../../protocol/zigbee/build/end-device-bind-stub-library-cortexm3-iar-efr32mg21-rail/: end-device-bind-stub-library.a
    ../../../protocol/zigbee/build/gp-library-cortexm3-iar-efr32mg21-rail/: gp-library.a
    ../../../protocol/zigbee/build/hal-library-cortexm3-iar-efr32mg21-rail/: hal-library.a
    ../../../protocol/zigbee/build/install-code-library-cortexm3-iar-efr32mg21-rail/: install-code-library.a
    ../../../protocol/zigbee/build/multi-network-stub-library-cortexm3-iar-efr32mg21-rail/: multi-network-stub-library.a
    ../../../platform/emdrv/nvm3/lib/: libnvm3_CM33_iar.a
    ../../../protocol/zigbee/build/packet-validate-stub-library-cortexm3-iar-efr32mg21-rail/: packet-validate-stub-library.a
    ../../../platform/radio/rail_lib/autogen/librail_release/: librail_efr32xg21_iar_release.a
    ../../../protocol/zigbee/build/security-library-core-cortexm3-iar-efr32mg21-rail/: security-library-core.a
    ../../../protocol/zigbee/build/security-library-link-keys-stub-cortexm3-iar-efr32mg21-rail/: security-library-link-keys-stub.a
    ../../../protocol/zigbee/build/sim-eeprom2-to-nvm3-upgrade-stub-library-cortexm3-iar-efr32mg21-rail/: sim-eeprom2-to-nvm3-upgrade-stub-library.a
    ../../../protocol/zigbee/build/zigbee-pro-stack-cortexm3-iar-efr32mg21-rail/: zigbee-pro-stack.a
    ../../../protocol/zigbee/build/zigbee-r22-support-stub-library-cortexm3-iar-efr32mg21-rail/: zigbee-r22-support-stub-library.a
    ../../../protocol/zigbee/build/zll-library-cortexm3-iar-efr32mg21-rail/: zll-library.a
